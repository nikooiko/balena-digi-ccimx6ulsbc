# TODO: implement this

IMAGE_FSTYPES_append_ccimx6sbc = " resinos-img"